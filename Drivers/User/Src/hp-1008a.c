#include "assert.h"
#include "inttypes.h"
#include "stdio.h"
#include "stdlib.h"
#include "stm32h7xx_hal.h"
#include "string.h"

#include "utils.h"

#define PRINT_STRIP_COLS 0x260
#define PRINT_STRIP_ROWS 0x080
#define PRINT_STRIP_SIZE (PRINT_STRIP_COLS * PRINT_STRIP_ROWS)

#define PRINT_OBUFF_SIZE (256 * 1024)

__ALIGN_BEGIN static uint8_t print_strip[PRINT_STRIP_SIZE] __ALIGN_END
    __attribute__((section(".sdram")));
__ALIGN_BEGIN static uint8_t print_trans[PRINT_STRIP_SIZE] __ALIGN_END
    __attribute__((section(".sdram")));
__ALIGN_BEGIN static uint8_t print_obuff[PRINT_OBUFF_SIZE] __ALIGN_END
    __attribute__((section(".sdram")));

// command 0x00
typedef struct __attribute__((packed)) {
  uint8_t command;
  uint8_t yres;
  uint16_t copies;
  uint8_t psize;
  uint16_t width;
  uint16_t height;
  uint8_t psrc;
  uint8_t resv1;
  uint8_t flip_l;
  uint8_t flip_s;
  uint8_t resv2;
  uint16_t resv3;
  uint8_t xres;
} hp_printer_command_new_job_t;

// command 0x01
typedef struct __attribute__((packed)) {
  uint8_t command;
  uint8_t resv[2];
} hp_printer_command_0x01_t;

// command 0x09
typedef struct {
  uint8_t command;
} hp_printer_command_stop_t;

// command 0x0c
typedef struct __attribute__((packed)) {
  uint8_t command;
  uint8_t index;
  uint16_t width;
  uint16_t height;
  uint8_t param1;
  uint32_t length;
} hp_printer_command_image_t;

// command 0x14
typedef struct __attribute__((packed)) {
  uint8_t command;
  uint8_t param0;
  uint8_t param1;
  uint8_t length;
  uint8_t resv[7];
} hp_printer_command_0x14_t;

char beg_token[] = "\x1B%-12345X";
char qpdl_command[] = "@PJL ENTER LANGUAGE = QPDL\r\n";
static uint8_t hp_printer_reenter_command(uint8_t *buf) {
  memcpy(buf, beg_token, sizeof(beg_token) - 1);
  return sizeof(beg_token) - 1;
}

// static uint8_t hp_printer_comment(uint8_t *buf, const char *str) {
//   return sprintf((char *)buf, "@PJL COMMENT %s\r\n", str);
// }

static uint8_t hp_printer_default_key_val(uint8_t *buf, const char *key, const char *val) {
  return sprintf((char *)buf, "@PJL DEFAULT %s=%s\r\n", key, val);
}

static uint8_t hp_printer_set_key_val(uint8_t *buf, const char *key, const char *val) {
  return sprintf((char *)buf, "@PJL SET %s=%s\r\n", key, val);
}

static uint8_t hp_printer_enter_qpdl_mode(uint8_t *buf) {
  memcpy(buf, qpdl_command, sizeof(qpdl_command));
  return sizeof(qpdl_command) - 1;
}

static uint8_t hp_printer_qpdl_new_job(uint8_t *buf, uint8_t res, uint16_t copies, uint8_t osize,
                                       uint16_t ow, uint16_t oh, uint8_t psrc) {
  hp_printer_command_new_job_t *command = (hp_printer_command_new_job_t *)buf;
  command->command = 0x00;
  command->yres = res;
  command->copies = htons(copies);
  command->psize = osize;
  command->width = htons(ow);
  command->height = htons(oh);
  command->psrc = psrc;
  command->resv1 = 0;
  command->flip_l = 0x00;
  command->flip_s = 0x00;
  command->resv2 = 0;
  command->resv3 = 0x0103;
  command->xres = res;

  return sizeof(hp_printer_command_new_job_t);
}

static uint8_t hp_printer_send_command_0x01(uint8_t *buf, uint8_t code1, uint8_t code2) {
  hp_printer_command_0x01_t *command = (hp_printer_command_0x01_t *)buf;
  command->command = 0x01;
  command->resv[0] = code1;
  command->resv[1] = code2;

  return sizeof(hp_printer_command_0x01_t);
}

static uint8_t hp_printer_qpdl_stop(uint8_t *buf) {
  hp_printer_command_stop_t *command = (hp_printer_command_stop_t *)buf;
  command->command = 0x09;
  return sizeof(hp_printer_command_stop_t);
}

static uint8_t hp_printer_send_command_0x14(uint8_t *buf, uint8_t code1, uint8_t code2,
                                            uint8_t *dbuf, uint8_t dlen) {
  *buf++ = 0x14;
  *buf++ = code1;
  *buf++ = code2;
  *buf++ = dlen;
  memcpy(buf, dbuf, dlen);
  return dlen + 4;
}

typedef struct {
  uint32_t token;
  uint32_t wsize;
} compressed_data_t;

typedef struct {
  char *cbeg;
  char *cend;
  compressed_data_t *head;
  char *ptr4;
} compressor_t;

int construct_plate(char *buffer, int height, int byte_width, int sensitivity, int *top_offs,
                    int *weights) {
  int total_bytes = height * byte_width;
  const char *buffer_end = buffer + total_bytes;

  // Use a local array for frequency tracking (similar to the 2048 int stack
  // buffer)
  int freq_cnt[1024];
  int freq_ids[1024];

  memset(freq_cnt, 0, sizeof(freq_cnt));
  for (int i = 0; i < 1024; ++i) {
    freq_ids[i] = -1 - i;
  }

  // 1. Sampling Loop: Count repetitions at various offsets
  int step_width = byte_width - 1;
  if (step_width > 1024 || step_width <= 0)
    step_width = 1024;

  int stride = (total_bytes - 1024) / step_width;

  const char *data_csr = buffer + 1024;
  do {
    char current_val = *data_csr;
    const char *lkup_csr = data_csr - 1;
    for (int offset = 0; offset < 1024; ++offset) {
      if (current_val == *lkup_csr) {
        freq_cnt[offset]++;
      }
      lkup_csr--;
    }
    data_csr += stride;
  } while (data_csr < buffer_end);

  // 2. Ranking: Find the Top 64 most frequent patterns
  // Using a simple selection sort logic as per the original ASM
  for (int i = 0; i < 64; ++i) {
    for (int j = i + 1; j < 1024; ++j) {
      if (freq_cnt[j] > freq_cnt[i]) {
        SWAP(freq_cnt[i], freq_cnt[j]);
        SWAP(freq_ids[i], freq_ids[j]);
      }
    }
    top_offs[i] = (uint32_t)freq_ids[i];
  }

  // 3. Threshold Generation: Create a weighting table
  if (sensitivity > 0 && sensitivity < 100) {
    int weight_val = 514;
    int step = 25700 / (sensitivity << 6); // Decrement factor

    for (int i = 0; i < 64; ++i) {
      weights[i] = MAX(3, weight_val);
      weight_val -= step;
    }
  } else {
    // Default static weights if sensitivity is out of range
    for (int i = 0; i < 64; ++i) {
      weights[i] = 0x202;
    }
  }
  return 0;
}

/**
 * sub_18002DDA0: LZ77-style Compression Engine
 *
 * Compresses input data using a dictionary-based approach.
 * It uses a pre-calculated offset table (from sub_18002DB90) to find matches.
 *
 * @param a1: Pointer to output structure/header. a1+8 is write pointer, a1+16
 * is limit.
 * @param a2: Input data pointer.
 * @param a3: Width.
 * @param a4: Height.
 * @param a5: Pointer to the offset table (generated by DB90).
 * @param Src: Initial dictionary/memory context.
 * @return: 0 on success, -3 (4294967293) if output buffer overflow.
 */
int64_t compress_using_plate(compressor_t *ctx, char *src_buf, int height, int byte_width,
                             int *top_offsets, // 之前 IdentifyDominantColors 找出的 64 个偏移
                             int *weights      // 之前生成的匹配长度阈值
) {
  int total_bytes = byte_width * height;
  char *input_ptr = src_buf;
  char *input_end = src_buf + total_bytes;

  char *dst = ctx->cend;
  char *output_limit = dst + (3 * total_bytes) / 4; // 压缩率保护：如果超过原图 3/4 则视为失败

  int literal_count = 0; // 记录无法压缩的连续原始字节数
  int min_offset = 0;    // 记录最远的回溯距离

  // 1. 初始化阶段：将 top_offsets 写入压缩包头部
  for (int i = 0; i < 64; ++i) {
    int offset = (int)top_offsets[i];
    if (offset < min_offset)
      min_offset = offset;

    // 在输出流记录偏移量信息（取反存储）
    *(int16_t *)dst = -(int16_t)offset;
    dst += 2;
  }

  // 在上下文结构体中记录最大回溯窗口（限制在 128 字节内）
  int window_size = MIN(128, -min_offset);
  ctx->head->wsize = window_size;

  // 2. 写入初始窗口数据（字面量复制）
  if (window_size > 0) {
    memcpy(dst, input_ptr, window_size);
    dst += window_size;
    input_ptr += window_size;
  }

  int remaining;
  char *literal_marker_ptr = NULL;
  // 3. 主压缩循环
  while (input_ptr < input_end) {
    remaining = input_end - input_ptr;
    if (remaining < 3)
      break; // 剩余字节太少，无法形成压缩指令

    int max_match_len = MIN(remaining, 514); // 最大匹配长度限制
    int longest_match = 0;
    int longest_index = 64; // 默认无效索引

    // 尝试 64 个主导偏移量，这64是是能匹配上的概率最大回溯长度
    for (int i = 0; i < 64; ++i) {
      char *backtrace_ptr = input_ptr + top_offsets[i];

      // 确保回溯位置合法且首字节匹配 (1-bit 模式下即匹配 8 个像素)
      if (backtrace_ptr >= src_buf && *input_ptr == *backtrace_ptr) {
        int current_match = 1;
        // 贪婪匹配后续字节
        while (current_match < max_match_len &&
               input_ptr[current_match] == backtrace_ptr[current_match]) {
          current_match++;
        }

        if (current_match > longest_match) {
          longest_match = current_match;
          longest_index = i;
          // 核心逻辑：如果匹配长度达到该偏移量的权重阈值，立即停止搜索（性能优化）
          if (current_match >= (int)weights[i])
            break;
        }
      }
    }

    // 4. 指令生成
    if (longest_match >= 3) {
      // 如果之前有待处理的字面量，先闭合字面量指令
      if (literal_count > 0) {
        *literal_marker_ptr = (char)(literal_count - 1);
        literal_count = 0;
      }

      // 生成压缩指令 (2 字节)
      // 格式：[1|Len-3(7bit)] [Index(6bit)|Len高位]
      int len_code = longest_match - 3;
      dst[0] = (char)(len_code | 0x80);
      dst[1] = (char)(longest_index | ((len_code >> 1) & 0xC0));
      dst += 2;

      input_ptr += longest_match;
    } else {
      // 5. 处理无法压缩的字面量
      if (literal_count == 0) {
        literal_marker_ptr = dst++; // 预留一个位置写字面量长度头
      }

      *dst++ = *input_ptr++;
      literal_count++;

      // 字面量段最大长度 128
      if (literal_count == 128) {
        *literal_marker_ptr = 127;
        literal_count = 0;
      }
    }

    // 压缩率溢出检查
    if (dst > output_limit)
      return -3; // 对应 4294967293 (0xFFFFFFFD)
  }

  // 闭合最后的字面量段
  if (literal_count > 0) {
    *literal_marker_ptr = (char)(literal_count - 1);
  }

  ctx->cend = dst;
  return ctx->cend - ctx->cbeg;
}
/**
 * sub_180030220: 32-bit Pixel Transpose/Byte-Swap (Optimized)
 *
 * Performs a complex byte-shuffle on 32-bit pixels, likely converting between
 * RGBA/ABGR or handling Endianness for blocks of 4x4 pixels (implied by
 * strides). Used when width and height are multiples of 4.
 *
 * @param a1: Input pixel buffer (uint32_t).
 * @param a2: Byte width.
 * @param a3: Height.
 * @param a4: Output buffer (int*).
 * @return: Result.
 */
int transpose_pixels_4bytes(const uint32_t *src, int width_bytes, int height, uint32_t *dst) {
  const int width_pixels = width_bytes >> 2;
  const int height_blocks = height >> 2; // 以4行为一组进行块处理
  const int total_pixels = height * width_pixels;

  uint32_t *dst_ptr = dst;

  for (int x = 0; x < width_pixels; ++x) {
    for (int y = 0; y < height_blocks; y += 1) {
      // 1. 读取当前列垂直相邻的 4 个像素
      uint32_t d1 = src[width_pixels * 0];
      uint32_t d2 = src[width_pixels * 1];
      uint32_t d3 = src[width_pixels * 2];
      uint32_t d4 = src[width_pixels * 3];

      // 2. 字节级重排 (Pixel Shuffling)
      // 逻辑：将 4 个像素的第 N 字节提取出来，组合成新的 uint32
      dst_ptr[height_blocks * 0] = ((d1 & 0x000000FF) >> 0x00) | ((d2 & 0x000000FF) << 0x08) |
                                   ((d3 & 0x000000FF) << 0x10) | ((d4 & 0x000000FF) << 0x18);
      dst_ptr[height_blocks * 1] = ((d1 & 0x0000FF00) >> 0x08) | ((d2 & 0x0000FF00) << 0x00) |
                                   ((d3 & 0x0000FF00) << 0x08) | ((d4 & 0x0000FF00) << 0x10);
      dst_ptr[height_blocks * 2] = ((d1 & 0x00FF0000) >> 0x10) | ((d2 & 0x00FF0000) >> 0x08) |
                                   ((d3 & 0x00FF0000) << 0x00) | ((d4 & 0x00FF0000) << 0x08);
      dst_ptr[height_blocks * 3] = ((d1 & 0xFF000000) >> 0x18) | ((d2 & 0xFF000000) >> 0x10) |
                                   ((d3 & 0xFF000000) >> 0x08) | ((d4 & 0xFF000000) << 0x00);

      src += width_pixels * 4;
      dst_ptr += 1;
    }
    // 指向下一列
    src = (src - total_pixels) + 1;
    dst_ptr = dst_ptr + 3 * height_blocks;
  }
  return 0;
}

int transpose_aligned_width(const uint32_t *src, int width, int height, char *dst) {
  const int total_pixels = width * height;
  const uint32_t *src_end = &src[total_pixels / 4]; // 这里原代码逻辑有点怪，a1是int*
  const char *dst_limit = &dst[total_pixels];
  const int stride = height;

  // 模式 B：小端/顺序分发
  while (src < src_end) {
    char *curr_dst = dst;
    while (curr_dst < dst_limit) {
      uint32_t pixel = *src++;

      curr_dst[0] = (uint8_t)pixel;                  // 字节 0
      curr_dst[stride] = (uint8_t)(pixel >> 8);      // 字节 1
      curr_dst[stride * 2] = (uint8_t)(pixel >> 16); // 字节 2
      curr_dst[stride * 3] = (uint8_t)(pixel >> 24); // 字节 3

      curr_dst += (stride * 4);
    }
    dst++;
  }
  return 0;
}

void transpose_pixels(char *src_buf, int byte_width, int height, char *dst_buf) {
  if (((height | byte_width) & 0x03) == 0) {
    transpose_pixels_4bytes((uint32_t *)src_buf, byte_width, height, (uint32_t *)dst_buf);
  } else if ((byte_width & 0x03) == 0) {
    transpose_aligned_width((uint32_t *)src_buf, byte_width, height, dst_buf);
  } else {
    for (int x = 0; x < byte_width; ++x) {
      const char *src_col_ptr = &src_buf[x];
      for (int y = 0; y < height; ++y) {
        *dst_buf++ = *src_col_ptr;
        src_col_ptr += byte_width;
      }
    }
  }
}

int compress_image_frame(char *dst, char *src, int byte_width, int height, int sensitivity,
                         int *top_offs, int *wight_buf) {
  compressor_t compressor;
  compressor.cbeg = dst;
  compressor.cend = dst + 8;
  compressor.head = (compressed_data_t *)dst;
  *(int32_t *)dst = 0x9ABCDEF;

  int status;

  if (byte_width == 1 || height == 1) {
    if (construct_plate(src, height, byte_width, (uint8_t)sensitivity, top_offs, wight_buf)) {
      return -2;
    }
  } else {
    transpose_pixels(src, (unsigned int)byte_width, (unsigned int)height, (char*)print_trans);
    if (construct_plate((char*)print_trans, height, byte_width, (uint8_t)sensitivity, top_offs,
                        wight_buf)) {
      return -2;
    }
  }
  status = compress_using_plate(&compressor, (char *)print_trans, height, byte_width, top_offs,
                                wight_buf);
  return status;
}

int top_offs[0x100];
int weights[0x40];

static uint8_t hp_printer_send_command_image(uint8_t *buf, uint8_t idx, int w, int h,
                                             uint8_t *data) {
  *buf++ = 0x0c;
  *buf++ = idx;
  *(uint16_t *)buf = htons(w * 8);
  buf += 2;
  *(uint16_t *)buf = htons(h);
  buf += 2;
  *buf++ = 0x11;

  int data_len = compress_image_frame((char *)buf + 4, (char *)data, w, h, 10, top_offs, weights);
  int buf_len = data_len + 4;
  *(uint32_t *)buf = htonl(buf_len);
  buf += 4;
  uint32_t sum = 0;
  for (int i = 0; i < data_len; i++) {
    sum += *(buf + i);
  }
  *(uint32_t *)(buf + data_len) = htonl(sum);
  return data_len + 15;
}

int hp_print() {
	memset(print_strip, 0, sizeof(print_strip));
  uint8_t *w_csr = print_obuff;

  w_csr += hp_printer_reenter_command(w_csr);
  w_csr += hp_printer_set_key_val(w_csr, "COPIES", "1");
  w_csr += hp_printer_set_key_val(w_csr, "COLORMODE", "MONO");
  w_csr += hp_printer_set_key_val(w_csr, "RESOLUTION", "600");
  w_csr += hp_printer_set_key_val(w_csr, "IMAGEQUALITY", "0");
  w_csr += hp_printer_default_key_val(w_csr, "SERVICEDATE", "20260425");
  w_csr += hp_printer_set_key_val(w_csr, "DUPLEX", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "PAPERTYPE", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "BANNERSHEET", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "TIMESTAMP", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "USERNAME", "\"liugc\"");
  w_csr += hp_printer_set_key_val(w_csr, "JOBNAME", "\"Microsoft Word - Document1\"");
  w_csr += hp_printer_set_key_val(w_csr, "HOSTMACHINENAME", "\"EL-ASUS-HERO\"");
  w_csr += hp_printer_set_key_val(w_csr, "HOSTJOBID", "\"0042551408\"");
  w_csr += hp_printer_set_key_val(w_csr, "ECONOMODE", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "ALTITUDE", "NORMAL");
  w_csr += hp_printer_set_key_val(w_csr, "XIGNOREFF", "OFF");
  w_csr += hp_printer_set_key_val(w_csr, "EDGEENHANCE", "NORMAL");
  w_csr += hp_printer_enter_qpdl_mode(w_csr);
  w_csr += hp_printer_qpdl_new_job(w_csr, 6, 1, 2, 2480, 3507, 1);
  w_csr += hp_printer_send_command_image(w_csr, 0, PRINT_STRIP_COLS, PRINT_STRIP_ROWS, print_strip);

  uint8_t data_buf[] = {0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00};
  w_csr += hp_printer_send_command_0x14(w_csr, 0x10, 0x18, data_buf, 0x08);

  data_buf[0] = 0x00;
  data_buf[1] = 0x00;
  data_buf[2] = 0x01;
  w_csr += hp_printer_send_command_0x14(w_csr, 0x11, 0x16, data_buf, 0x03);

  w_csr += hp_printer_send_command_0x14(w_csr, 0x12, 0x12, data_buf, 0x02);

  w_csr += hp_printer_send_command_0x01(w_csr, 0x00, 0x01);
  w_csr += hp_printer_qpdl_stop(w_csr);
  w_csr += hp_printer_reenter_command(w_csr);
  return w_csr - print_obuff;
}